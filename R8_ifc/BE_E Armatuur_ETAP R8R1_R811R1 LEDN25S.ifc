Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-12-23T11:55:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161117_1200(x64) - Exporter 17.0.1099.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 23 11:55:49 2016 * Host: WITAS2 * Database: C:\Users\WITAS_~1\AppData\Local\Temp\{543B4D53-6566-4258-8571-CE3D056A50CA}\ifc * Database version: 5507 * Database creation date: Fri Dec 23 11:55:48 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 23 11:55:48 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 23 11:55:48 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: R811R1 LEDN25S, Dummy:R811R1 LEDN25S:206161
In: Level 1
Type - Material: BE Armatuur, BE_G Glas lamp
Type - Constraints - Default Elevation: 2000 mm; WT_H Behuizing: Standaard; WT_H Bevestiging: Pendel - 2 pendelkabels; WT_H Coarse geometrie: Standaard; WT_H Opbouw: no; WT_H Pendel horizontale armatuurmontage: yes; WT_H Referentie: Pendel - horizontale armatuurmontage; WT_H Symbool plafond hoogte: 80 mm; WT_H Symbool plafond lengte: 787 mm; WT_H Symbool wand hoogte: 80 mm; WT_H Symbool wand lengte: 787 mm
Type - Dimensions - BE_G Breedte: 80 mm; BE_G Diameter: 80 mm; BE_G Hoogte: 121 mm; BE_G Lengte: 787 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 224 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 224 W
Type - Graphics - WT_V Symbool plafond: rectangular - luminaire - led; WT_V Symbool wand: none_gen
Type - Identity Data - BE_I Bestelcode: R811R1/LEDN25S; Manufacturer: ETAP; Model: R8R1; Type Name: R811R1 LEDN25S; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur
Type - Model Properties - WT_I Armatuurrendement: 0; WT_I Kleur: RAL9003; WT_I Lampkleur: 4000; WT_I Lichtstroom armatuur: 2444; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: 850°C; WT_I Montage: pendel; WT_I Optiek: diffusor; WT_I Type: individueel; WT_I UGR: <=25; WT_I Voorschakelapparaat: S; WT_I Vorm: langwerpig
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP R8R1 - lichtbron: R811R1_LEDN25_S; WT_I Aantal lampen: 1; WT_I Afschermhoek: 0 deg; WT_I Lamptype: Low PowerLed; WT_I Luminantie: 0; WT_I Vermogen lamp: 224 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: R811R1 LEDN25S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Offset lichtbron: 381.6 mm; WT_H Pendelhoogte: 341.6 mm
Construction - WT_V Pendelhoogte: 300 mm
Dimensions - Area: 0.104112 m2; Volume: 0.00395586 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-224 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 5
Other - Family: Dummy: R811R1 LEDN25S; Family and Type: Dummy: R811R1 LEDN25S; Schedule Level: Level: Level 1; Type: Dummy: R811R1 LEDN25S; Type Id: Dummy: R811R1 LEDN25S
Phasing - Phase Created: 64113
